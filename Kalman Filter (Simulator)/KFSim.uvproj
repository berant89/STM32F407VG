# Keil uVision project KFSim.uvproj, settings and files
target KFSim (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: KFSim
  c flags: Optim=1
  c misc: --c99
  c include: .\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ASM
    ./ASM/: startup_stm32f40xx.s kalman.s
  group Include
    ./Include/: kalman_filter.h
  group Source
    ./Source/: main.c fputc_debug.c
